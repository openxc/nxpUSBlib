# IAR project LPCUSBlib.ewp, settings and files
configuration LPC11Uxx_Device (ARM, debug)
  General.OGChipSelectEditMenu: LPC11U14 NXP LPC11U14
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __LPC11UXX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\CDL\LPC11UxxLib\inc; ..\CDL\CMSISv2p00_LPC11Uxx\lpcinc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: LPCUSBlib.out
configuration LPC17xx_Device (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __LPC17XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC17xx\lpcinc; ..\CDL\LPC17xxLib\inc
configuration LPC43xx_Device (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: __LPC43XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC43xx\inc; ..\CDL\CMSISv2p00_LPC43xx\lpcinc; ..\CDL\LPC43xxLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration LPC18xx_Device (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCDefines: __LPC18XX__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC18xx\inc; ..\CDL\CMSISv2p00_LPC18xx\lpcinc; ..\CDL\LPC18xxLib\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
configuration LPC177x_8x_Device (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  ICCARM.CCDefines: __LPC177X_8X__; USB_DEVICE_ONLY
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC177x_8x\inc; ..\CDL\CMSISv2p00_LPC177x_8x\lpcinc; ..\CDL\LPC177x_8xLib\inc
configuration LPC17xx_Host (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __LPC17XX__; USB_HOST_ONLY
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC17xx\inc; ..\CDL\CMSISv2p00_LPC17xx\lpcinc; ..\CDL\LPC17xxLib\inc
configuration LPC177x_8x_Host (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  ICCARM.CCDefines: __LPC177X_8X__; USB_HOST_ONLY
  ICCARM.CCIncludePath2: as above
configuration LPC18xx_Host (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCDefines: __LPC18XX__; USB_HOST_ONLY
  ICCARM.CCIncludePath2: ..\CDL\CMSISv2p00_LPC18xx\lpcinc; ..\CDL\LPC18xxLib\inc
  ICCARM.CCOptLevel: 3
configuration LPC43xx_Host (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: __LPC43XX__; USB_HOST_ONLY
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration LPC18xx_DeviceHost (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1850 NXP LPC1850
  ICCARM.CCDefines: __LPC18XX__
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
configuration LPC17xx_DeviceHost (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1768 NXP LPC1768
  ICCARM.CCDefines: __LPC17XX__
  ICCARM.CCIncludePath2: as above
configuration LPC177x_8x_DeviceHost (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC1788 NXP LPC1788
  ICCARM.CCDefines: __LPC177X_8X__
  ICCARM.CCIncludePath2: as above
configuration LPC43xx_DeviceHost (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: LPC4350_M4 NXP LPC4350_M4
  ICCARM.CCDefines: __LPC43XX__
  ICCARM.CCIncludePath2: as above
  ICCARM.CCOptLevel: 3
  group (top)
    ./: LPCUSBlibConfig.h
  group Drivers/USB/Class/Common
    Drivers/USB/Class/Common/: HIDParser.c
  group Drivers/USB/Class/Device
    Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
  group Drivers/USB/Class/Host
    Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c StillImageClassHost.c
  group Drivers/USB/Core
    Drivers/USB/Core/: ConfigDescriptor.c DeviceStandardReq.c Events.c HostStandardReq.c USBMemory.c USBTask.c
  group Drivers/USB/Core/LPC
    Drivers/USB/Core/LPC/: Device_LPC.c Endpoint_LPC.c EndpointStream_LPC.c Host_LPC.c Pipe_LPC.c PipeStream_LPC.c USBController_LPC.c
  group Drivers/USB/Core/LPC/DCD/LPC11UXX
    Drivers/USB/Core/LPC/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
  group Drivers/USB/Core/LPC/DCD/LPC17XX
    Drivers/USB/Core/LPC/DCD/LPC17XX/: Endpoint_LPC17xx.c
  group Drivers/USB/Core/LPC/DCD/LPC18XX
    Drivers/USB/Core/LPC/DCD/LPC18XX/: Endpoint_LPC18xx.c
  group Drivers/USB/Core/LPC/DCD/USBRom
    Drivers/USB/Core/LPC/DCD/USBRom/: usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c
  group Drivers/USB/Core/LPC/HAL/LPC11UXX
    Drivers/USB/Core/LPC/HAL/LPC11UXX/: HAL_LPC11Uxx.c
  group Drivers/USB/Core/LPC/HAL/LPC17XX
    Drivers/USB/Core/LPC/HAL/LPC17XX/: HAL_LPC17xx.c
  group Drivers/USB/Core/LPC/HAL/LPC18XX
    Drivers/USB/Core/LPC/HAL/LPC18XX/: HAL_LPC18xx.c
  group Drivers/USB/Core/LPC/HCD
    Drivers/USB/Core/LPC/HCD/: HCD.c
  group Drivers/USB/Core/LPC/HCD/EHCI
    Drivers/USB/Core/LPC/HCD/EHCI/: EHCI.c
  group Drivers/USB/Core/LPC/HCD/OHCI
    Drivers/USB/Core/LPC/HCD/OHCI/: OHCI.c
