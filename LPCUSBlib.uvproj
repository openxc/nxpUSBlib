# Keil uVision project LPCUSBlib.uvproj, settings and files
target LPC11Uxx_Device (ARM-ADS)
  device: LPC11U14/201 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10000FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: LPCUSBlib_LPC11Uxx_Device (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC11UXX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC11Uxx\inc;..\CDL\CMSISv2p00_LPC11Uxx\lpcinc;..\CDL\LPC11UxxLib\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x1000
  group Class
    ./Drivers/USB/Class/Common/: HIDParser.c
    ./Drivers/USB/Class/Device/: AudioClassDevice.c CDCClassDevice.c HIDClassDevice.c MassStorageClassDevice.c MIDIClassDevice.c RNDISClassDevice.c
    ./Drivers/USB/Class/Host/: AudioClassHost.c CDCClassHost.c HIDClassHost.c MassStorageClassHost.c MIDIClassHost.c PrinterClassHost.c RNDISClassHost.c StillImageClassHost.c
  group Core
    ./Drivers/USB/Core/: ConfigDescriptor.c DeviceStandardReq.c Events.c HostStandardReq.c USBTask.c USBMemory.c
  group LPC
    ./Drivers/USB/Core/LPC/: Device_LPC.c Endpoint_LPC.c EndpointStream_LPC.c Host_LPC.c Pipe_LPC.c PipeStream_LPC.c USBController_LPC.c
  group HAL
    ./Drivers/USB/Core/LPC/HAL/LPC18XX/: HAL_LPC18xx.c
    ./Drivers/USB/Core/LPC/HAL/LPC17XX/: HAL_LPC17xx.c
    ./Drivers/USB/Core/LPC/HAL/LPC11UXX/: HAL_LPC11Uxx.c
  group HCD
    ./Drivers/USB/Core/LPC/HCD/: HCD.c
    ./Drivers/USB/Core/LPC/HCD/OHCI/: OHCI.c
    ./Drivers/USB/Core/LPC/HCD/EHCI/: EHCI.c
  group DCD
    ./Drivers/USB/Core/LPC/DCD/LPC11UXX/: Endpoint_LPC11Uxx.c
    ./Drivers/USB/Core/LPC/DCD/LPC17XX/: Endpoint_LPC17xx.c
    ./Drivers/USB/Core/LPC/DCD/LPC18XX/: Endpoint_LPC18xx.c
    ./Drivers/USB/Core/LPC/DCD/USBRom/: usbd_cdc.c usbd_hid.c usbd_msc.c usbd_rom.c
  group Config
    ./: LPCUSBlibConfig.h
target LPC177x_8x_Host (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x1000FFFF) IRAM2(0x20000000-0x20007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPCUSBlib_LPC177x_8x_Host (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC177X_8X__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC177x_8x\inc;..\CDL\LPC177x_8xLib\inc;..\CDL\CMSISv2p00_LPC177x_8x\lpcinc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target LPC177x_8x_Device (ARM-ADS)
  device: LPC1788 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC177x_8x_Device (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC177X_8X__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
target LPC17xx_Host (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPCUSBlib_LPC17xx_Host (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC17XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC17xx\inc;..\CDL\LPC17xxLib\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC17xx_Device (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC17xx_Device (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC17XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC17xx\inc;..\CDL\CMSISv2p00_LPC17xx\lpcinc;..\CDL\LPC17xxLib\inc
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
target LPC18xx_Host (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10017FFF) IRAM2(0x20000000-0x2000FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: LPCUSBlib_LPC18xx_Host (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC18xx\inc;..\CDL\LPC18xxLib\inc
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC18xx_Device (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC18xx_Device (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC18xx\inc;..\CDL\LPC18xxLib\inc
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC43xx_Host (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: LPCUSBlib_LPC43xx_Host (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_HOST_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\LPC43xxLib\inc;..\CDL\CMSISv2p00_LPC43xx\lpcinc
  asm define: NO_CRP
target LPC43xx_Device (ARM-ADS)
  device: Cortex-M4 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE
  output: LPCUSBlib_LPC43xx_Device (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC43XX__ USB_DEVICE_ONLY
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC43xx\inc;..\CDL\CMSISv2p00_LPC43xx\lpcinc;..\CDL\LPC43xxLib\inc
  asm define: NO_CRP
target LPC18xx_HostDevice (ARM-ADS)
  device: LPC1850 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC18xx_HostDevice (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC18XX__
  c misc: --gnu --c99 --diag_suppress=1207
  c include: ..\CDL\CMSISv2p00_LPC18xx\inc;..\CDL\CMSISv2p00_LPC18xx\lpcinc;..\CDL\LPC18xxLib\inc
  asm define: NO_CRP
  memory RVCT9: RAM 0x10000000 size 0x18000
  memory RVCT10: RAM 0x20000000 size 0x10000
target LPC17xx_HostDevice (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: as above
  output: LPCUSBlib_LPC17xx_HostDevice (library)
  c flags: Optim=1 OneElfS=1
  c define: __LPC17XX__
  c misc: --gnu --c99 --diag_suppress=1207
  c include: as above
  asm define: NO_CRP
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
